# IAR project ZASA.ewp, settings and files
configuration CC2480 EndDevice (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 324
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ENDDEVICE; APP_BLINK_LEDS
  ICC430.CCDiagSuppress: Pe068
  ICC430.IExtraOptions: -f ..\Source\ZASA.cfg
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\Source; ..\..\common\zaccel; ..\..\common\mt; ..\..\target\include; ..\..\target\cc2480
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration CC2480 Router (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ROUTER; APP_BLINK_LEDS
  ICC430.CCOptLevel: 3
configuration CC2480 Coordinator (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: COORDINATOR; HOST_MT; APP_BLINK_LEDS
  ICC430.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f2274.xcl
  group App
    ../Source/: ZASA.cfg ZASA.h ZASA_coord.c ZASA_enddev.c ZASA_main.c ZASA_router.c
  group HAL
    ../../common/zaccel/: cc2480.h
    ../../target/cc2480/: hal_board.c hal_board.h
    ../../target/include/: hal_defs.h hal_types.h
  group MT
    ../../common/mt/: mt.c mt.h
  group SAPI
    ../../common/zaccel/: sapi.c sapi.h sapi_cb.c
  group ZAccel
    ../../common/zaccel/: spi.c spi.h zaccel.c zaccel.h
